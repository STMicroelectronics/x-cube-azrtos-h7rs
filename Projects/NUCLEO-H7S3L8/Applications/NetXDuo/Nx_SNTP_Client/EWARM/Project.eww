<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\Nx_SNTP_Client_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
