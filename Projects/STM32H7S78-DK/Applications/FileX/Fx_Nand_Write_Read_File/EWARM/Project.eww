<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\Fx_Nand_Write_Read_File_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
