<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\Nx_MQTT_Client_wifi_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
