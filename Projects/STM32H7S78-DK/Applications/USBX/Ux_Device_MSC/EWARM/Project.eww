<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\Ux_Device_MSC_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
