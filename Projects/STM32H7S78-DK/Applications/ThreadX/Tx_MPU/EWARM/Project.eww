<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Appli\Tx_Module_Appli.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Appli\Tx_Module_Manager_Appli.ewp</path>
    </project>
    <batchBuild />
</workspace>
